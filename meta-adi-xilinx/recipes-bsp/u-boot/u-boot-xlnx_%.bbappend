FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_microblaze = " file://microblaze.cfg"
