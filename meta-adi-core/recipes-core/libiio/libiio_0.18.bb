SRCREV = "c5e0ff9afc951c5469f1ff0049f39c32be7f602f"

require libiio.inc
